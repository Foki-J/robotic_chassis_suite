# Keil uVision project Dark_Destroyer.uvprojx, settings and files
target Dark_Destroyer (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Dark_Destroyer +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\bsp\inc;..\core;..\stdlib\inc;..\system\sys;..\system\delay;..\task\inc;..\user;..\pieceFSh1t\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: stm32f4xx_it.c main.c
  group stdlib
    ../stdlib/src/: stm32f4xx_gpio.c misc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_i2c.c
  group bsp
    ../bsp/scr/: gpio.c tim.c usart.c exti.c i2c.c can.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ./: system_stm32f4xx.c
  group core
    ../core/: startup_stm32f40_41xxx.s
  group task
    ../task/scr/: software_Debug.c control.c init.c
  group pieceFshit
    ../pieceFSh1t/src/: DataScope_DP.C inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
